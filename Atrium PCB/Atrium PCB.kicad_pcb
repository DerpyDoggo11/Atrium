# Repository DerpyDoggo11/Atrium

File README.md:

# Atrium
The weirdest keyboard you've seen

## 3D Model Preview

## 3D PCB Preview

## Wiring

## Schematic

## Introduction
Most keyboards are functional, but a little boring. They dont have much complexity, and for as much space as it takes up on your desktop, I think it deserves more attention. So naturally, this led me a rabbit hole of finding the most outrageously useless (or useful depending on how you see it) features to a keyboard while still keeping it useable. This culminated into Atrium, a compact 40% ergonomic transparent keyboard with a full background RGB LED display, accelerometer, a speaker (idk why youd need this honestly), 8 external buttons (also dont really have a complete use for this, maybe for a funny looking gaming console?), and an sd card reader. The keyboard is all based on a single 2 layer pcb which can be fabricated through a service like JLCPCB.

The background display is the critical component of the keyboard, I imagine it looking really cool for fluid and boid simulations. However, the size restraints of the display for a decently acceptable level of resolution meant that I couldn't use regular key switches. To make this work the pcb has hall effect sensors below each magnetic switch to detect the changing magnetic field and then register a press. All of these switches are mounted on a piece of plexiglass above the pcb itself.

## Bill of Materials 

| Quantity | Components | Price | Link |
|--------- |----------|----------| -----|
| 2 | 200x300x3mm Plexiglass sheet | $20 | [here](https://www.aliexpress.us/item/3256807722386926.html?spm=a2g0o.productlist.main.2.39f129e2SERr2S&algo_pvid=185f7068-e484-4aa3-9ff3-0e65a2acbd56&algo_exp_id=185f7068-e484-4aa3-9ff3-0e65a2acbd56-1&pdp_ext_f=%7B%22order%22%3A%22156%22%2C%22eval%22%3A%221%22%2C%22fromPage%22%3A%22search%22%7D&pdp_npi=6%40dis%21USD%218.44%215.23%21%21%2156.35%2134.94%21%402101c4ea17891631287926600e102c%2112000042797704390%21sea%21US%217493938711%21X%211%210%21n_tag%3A-29919%3Bd%3Ad260408f%3Bm03_new_user%3A-29895&curPageLogUid=IFVzF4QWo7zW&utparam-url=scene%3Asearch%7Cquery_from%3A%7Cx_object_id%3A1005007908701678%7C_p_origin_prod%3A)
| 40 | Cherry MX size (14mm) Magnetic Switches | $35 |[here](https://www.amazon.com/KPREPUBLIC-Ice-Magnetic-Ultra-Switch/dp/B0F2TCCYWP?crid=I18TQ6WCZ55V&dib=eyJ2IjoiMSJ9.78J6AGarRQEMe0vTq8MGYLsxi-S4JBDiDRFAosFVx6_VF4t3cJ96uidIVCECAGzF25KllPLyLHb92NJ_lEqfo1-gvFnc_Fb6D9Iair7aUHSxG23V4wG2haL1KBqHgXqXCmF1R7FXjrgNCZcwF3E_cyp0AIlmCZVgh__9aZx_8NhSv6mvjCwJ1vqvtoQLOhn_J3bUNSnNhFdLBvh5NzHbx5Rjh5HcFxqc6zd1yXfZoDY.UsFUvTRnK5RhONAHTDqrIzdRvolbcLwU5a02U6N0Xw4&dib_tag=se&keywords=transparent%2Bhall%2Beffect%2Bswitches&qid=1791690004&sprefix=transparenthall%2Beffect%2Bswitches%2Caps%2C330&sr=8-1&th=1) 
| 3 | M4 bolts and nuts | $12 | [here](https://www.aliexpress.us/item/3256807092650644.html?spm=a2g0o.productlist.main.1.675a7aa5twLngJ&algo_pvid=d4270fee-9c36-4b22-9c88-86ae13a58121&algo_exp_id=d4270fee-9c36-4b22-9c88-86ae13a58121-0&pdp_ext_f=%7B%22order%22%3A%229119%22%2C%22eval%22%3A%221%22%2C%22fromPage%22%3A%22search%22%7D&pdp_npi=6%40dis%21USD%215.26%215.26%21%21%2135.03%2135.03%21%402101ca9517916959045395475e12b4%2112000040076085093%21sea%21US%217493938711%21X%211%210%21n_tag%3A-29919%3Bd%3Ad260408f%3Bm03_new_user%3A-29895&curPageLogUid=tqNMsgS5ewqS&utparam-url=scene%3Asearch%7Cquery_from%3A%7Cx_object_id%3A1005007278965396%7C_p_origin_prod%3A) 
| 1 | PCBA for Atrium (comes with 2) | $400 | Upload PCB fabrication files to JLCPCB.   

Total cost: **$467**

Cost per pen: **$234**

----

## Tools / Other parts:
- Screwdriver
- Computer to flash firmware 

## Assembly
1. Cut the plexiglass sheets to the correct shapes (print a small cutout to help)
2. Flash firmware onto the Atrium pcb
3. Assemble together with bolts and spacers
4. Add felt or rubber pads to the feet at the 5 corners

## KiCad design Atrium PCB/Atrium PCB.kicad_pcb

Schematic: Atrium PCB.kicad_sch

Parts:
C3, C11, C12, C13, C14, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C62, C64, C82, C83, C84, C85, C86, C87, C88, C89, C90, C91, C92, C93, C94, C95, C96, C97, C98, C99, C100, C101, C102, C103, C104, C105, C106, C107, C108, C109, C110, C111, C112, C113, C114, C115, C116, C117, C118, C119, C120, C122, C123, C124, C125, C126, C127, C128, C129, C130, C131, C132, C133, C134, C135, C136, C137, C138, C139, C140, C141, C142, C143, C144, C145, C146, C147, C148, C149, C150, C151, C152, C153, C154, C155, C156, C158, C159, C160, C161, C162, C163, C164, C165, C166, C167, C168, C169, C170, C171, C172, C173, C174, C175, C176, C177, C178, C179, C180, C181, C182, C183, C184, C185, C186, C187, C188, C189, C191, C192, C193, C194, C195, C196, C197, C198, C199, C200, C201, C202, C203, C204, C205, C206, C207, C208, C209, C210, C212, C213, C214, C215, C216, C217, C218, C219, C220, C221, C222, C223, C224, C225, C226, C227, C228, C230, C231, C232, C233, C234, C235, C236, C237, C238, C239, C240, C241, C242, C243, C244, C245, C246, C247, C248, C249, C250, C251, C252, C253, C254, C255, C256, C257, C258, C259, C260, C261, C262, C263, C264, C265, C266, C267, C268, C269, C270, C271, C272, C273, C274, C275, C276, C277, C278, C279, C280, C281, C282, C283, C284, C285, C286, C287, C288, C289, C290, C291, C292, C293, C294, C295, C296, C297, C298, C299, C300, C302, C303, C304, C305, C306, C307, C308, C309, C310, C311, C312, C313, C314, C315, C316, C317, C318, C319, C320, C321, C322, C323, C324, C325, C326, C327, C328, C329, C330, C331, C332, C333, C334, C335, C336, C337, C338, C339, C340, C341, C342, C343, C344, C345, C346, C347, C348, C349, C350, C351, C352, C353, C354, C355, C356, C357, C358, C359, C360, C361, C362, C363, C364, C365, C366, C367, C368, C369, C370, C371, C372, C373, C374, C375, C376, C377, C378, C379, C380, C381, C425, C426, C427, C428, C429, C430, C431, C432, C433, C434, C435, C436, C437, C438, C439, C440, C441, C442, C443, C444, C445, C446, C447, C448, C449, C450, C451, C452, C453, C454, C455, C456, C457, C458, C459, C460, C461, C462, C463, C464, C465, C466, C467, C468, C469, C470, C471, C472, C473, C474, C475, C476, C477, C478, C479, C480, C481, C482, C483, C484, C485, C486, C487, C488, C489, C490, C491, C492, C493, C494, C495, C496, C497, C498, C499, C500, C501, C502, C503, C504, C505, C506, C507, C508, C509, C510, C511, C512, C513, C514, C515, C516, C517, C518, C519, C520, C521, C522, C523, C524, C525, C526, C527, C528, C529, C530, C531, C532, C533, C534, C535, C536, C537, C538, C539, C540, C541, C542, C543, C544, C549, C550, C551, C552, C553, C554: 100nF; C_0603_1608Metric; LCSC Part C14663
C4, C5, C6, C10: 4.7uF; C_0603_1608Metric; LCSC Part C19666
C7, C8: 15pF; C_0603_1608Metric; LCSC Part C1644
C9: 1nF; C_0603_1608Metric; LCSC Part C1588
C15, C63, C400: 10uF; C_0805_2012Metric; LCSC Part C15850
C27: 10nF; C_0603_1608Metric; LCSC Part C57112
C65: 1uF; C_0603_1608Metric; LCSC Part C15849
C211: 22uF; C_0402_1005Metric; LCSC Part C3854737
C301, C382, C383, C384, C385, C386, C387, C388, C389, C390, C391, C392, C393, C394, C395, C396, C397, C398, C399, C402, C403, C404, C405, C406, C407, C408, C409, C410, C411, C412, C413, C414, C415, C416, C417, C418, C419, C420, C421, C422, C423, C424, C546, C547, C548: 100nF; C_0402_1005Metric; LCSC Part C1525
C401: 100uF; C_1206_3216Metric; LCSC Part C15008
Card1: TF PUSH; TF-SMD_TF-PUSH; MPN TF PUSH; LCSC Part C393941
D1, D2, D3, D6, D7, D8, D9, D11, D12, D13, D14, D16, D17, D18, D20, D21, D22, D24, D25, D26, D28, D29, D30, D32, D33, D34, D36, D37, D38, D40, D41, D42, D43, D44, D45, D46, D48, D49, D50, D51, D52: D; D_0603_1608Metric; not fitted
D5: USBLC6-2SC6_C2687116; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; MPN USBLC6-2SC6; LCSC Part C2687116
F1: 3A; Fuse_1206_3216Metric
FB1: Ferrite 600R@100MHz; L_0805_2012Metric
FLASH1: W25Q128JVS; SOIC-8_5.3x5.3mm_P1.27mm
FPC1: FPC-05F-12PH20; FPC-SMD_12P-P0.50_FPC-05F-12PH20; MPN FPC-05F-12PH20; LCSC Part C2856799; not fitted
J1: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
L1: 3.3uH; L_1210_3225Metric
LED1: VEML7700-TR; LED-SMD_4P-L6.8-W2.4_VEML7700-TR; MPN VEML7700-TR; LCSC Part C504893
LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED48, LED49, LED50, LED51, LED52, LED53, LED54, LED55, LED56, LED57, LED58, LED59, LED60, LED61, LED62, LED63, LED64, LED65, LED66, LED67, LED68, LED69, LED70, LED71, LED72, LED73, LED74, LED75, LED76, LED77, LED78, LED79, LED80, LED81, LED82, LED83, LED84, LED85, LED87, LED88, LED89, LED90, LED91, LED92, LED93, LED94, LED95, LED96, LED97, LED98, LED99, LED100, LED101, LED102, LED103, LED104, LED105, LED106, LED107, LED108, LED109, LED110, LED111, LED112, LED113, LED114, LED115, LED116, LED117, LED118, LED119, LED120, LED121, LED123, LED124, LED125, LED126, LED127, LED128, LED129, LED130, LED131, LED132, LED133, LED134, LED135, LED136, LED137, LED138, LED139, LED140, LED141, LED142, LED143, LED144, LED146, LED147, LED148, LED149, LED150, LED151, LED152, LED153, LED154, LED155, LED156, LED157, LED158, LED159, LED160, LED161, LED162, LED163, LED164, LED166, LED167, LED168, LED169, LED170, LED171, LED172, LED173, LED174, LED175, LED176, LED177, LED178, LED179, LED180, LED181, LED182, LED183, LED184, LED185, LED186, LED187, LED188, LED189, LED190, LED191, LED192, LED193, LED194, LED195, LED196, LED197, LED198, LED199, LED200, LED201, LED202, LED203, LED204, LED205, LED206, LED207, LED208, LED209, LED210, LED211, LED212, LED213, LED214, LED215, LED216, LED217, LED218, LED219, LED220, LED221, LED222, LED223, LED224, LED225, LED226, LED227, LED228, LED229, LED230, LED231, LED232, LED233, LED234, LED235, LED236, LED237, LED238, LED239, LED240, LED241, LED242, LED243, LED244, LED245, LED246, LED247, LED248, LED249, LED250, LED251, LED252, LED253, LED254, LED255, LED256, LED257, LED258, LED259, LED260, LED261, LED262, LED263, LED264, LED265, LED266, LED267, LED268, LED269, LED270, LED271, LED272, LED273, LED274, LED275, LED276, LED277, LED278, LED279, LED280, LED281, LED282, LED283, LED284, LED285, LED286, LED287, LED288, LED289, LED290, LED291, LED292, LED293, LED294, LED295, LED296, LED297, LED298, LED299, LED300, LED301, LED302, LED303, LED304, LED305, LED306, LED307, LED308, LED309, LED310, LED311, LED312, LED313, LED314, LED315, LED316, LED317, LED318, LED319, LED320, LED321, LED322, LED323, LED324, LED325, LED326, LED327, LED328, LED329, LED330, LED331, LED332, LED333, LED334, LED335, LED336, LED337, LED338, LED339, LED340, LED341, LED342, LED343, LED344, LED345, LED346, LED347, LED348, LED349, LED350, LED351, LED352, LED353, LED354, LED355, LED356, LED357, LED358, LED359, LED360, LED361, LED362, LED363, LED364, LED365, LED366, LED367, LED368, LED369, LED370, LED371, LED372, LED373, LED374, LED375, LED376, LED377, LED378, LED379, LED380, LED381, LED382, LED383, LED384, LED385, LED386, LED387, LED388, LED389, LED390, LED391, LED392, LED393, LED394, LED395, LED396, LED399, LED402, LED411, LED414, LED426, LED435, LED436, LED437, LED439, LED440, LED441, LED442, LED443, LED447, LED448, LED449, LED451, LED452, LED453, LED454, LED459, LED460, LED463, LED464, LED466, LED471, LED472, LED475, LED476, LED477, LED478: SK6805-EC15; LED-SMD_4P-L1.5-W1.5-BL; MPN SK6805-EC15; LCSC Part C2890035
R3, R7, R8: 1k; R_0603_1608Metric; LCSC Part C21190
R6: 33; R_0603_1608Metric; LCSC Part C23140
R10, R13: 470; R_0603_1608Metric; LCSC Part C23179
R28, R29, R30, R31, R36, R37: 10k; R_0603_1608Metric; LCSC Part C25804
R32, R33: 5.1k; R_0603_1608Metric; LCSC Part C23186
R34, R35: 27; R_0603_1608Metric; LCSC Part C25190
R40, R41: 4.7k; R_0402_1005Metric; LCSC Part C25900
RP2350: RP2350A; QFN-60-1EP_7x7mm_P0.4mm_EP3.4x3.4mm
SPK1: GSPK2308P-8R0.5W; SPK-TH_BD23.0-P10.00-D0.8-L-RD; MPN GSPK2308P-8R0.5W; LCSC Part C530532
SW1: EC11E09244BS; SW-TH_EC11XXXXXXXX; MPN EC11E09244BS; LCSC Part C470742; not fitted
SW2, SW3: SKRPACE010; KEY-SMD_4P-L4.2-W3.2-P2.20-LS4.6; MPN SKRPACE010; LCSC Part C139797
SW4, SW5, SW6, SW8, SW9, SW10, SW11, SW13, SW14, SW15, SW16, SW18, SW19, SW20, SW22, SW23, SW24, SW26, SW27, SW28, SW30, SW31, SW32, SW34, SW35, SW36, SW38, SW39, SW40, SW42, SW43, SW44, SW45, SW46, SW47, SW48, SW50, SW51, SW52, SW53, SW54: SW_Push; SW_Cherry_MX_PCB; not fitted
SW41, SW49, SW55, SW56, SW57, SW58, SW59, SW60: FG-TC-12E-02-8H; SW-TH_FG-TC-12E-02-8H; MPN FG-TC-12E-02-8H; LCSC Part C54141282
TP18, TP19, TP20, TP21, TP22: Breakout; TestPoint_Pad_D1.5mm
U1, U4, U5, U7, U8, U9, U10, U11, U13, U14, U15, U16, U17, U19, U20, U21, U22, U23, U24, U25, U27, U28, U29, U30, U31, U32, U33, U34, U35, U36, U37, U38, U39, U40, U41, U42, U44, U45, U46, U47: CH604ASR; SOT-23-3_L2.9-W1.6-P1.90-LS2.8-BR; MPN CH604ASR; LCSC Part C2830877
U2: LSM6DS3TR-C; LGA-14_L3.0-W2.5-P0.50-TL; MPN LSM6DS3TR-C; LCSC Part C967633
U3, U18, U43: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm
U6: SN74LVC1T45DBVR; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR
U12: AP2112K-3.3; SOT-23-5
U48: MAX98357A; TQFN-16-1EP_3x3mm_P0.5mm_EP1.23x1.23mm
USB1: USB-TYPE-C-018; USB-C_SMD-TYPE-C-31-M-12; MPN USB-TYPE-C-018; LCSC Part C2927038
X1: X322512MSB4SI; CRYSTAL-SMD_4P-L3.2-W2.5-BL; MPN X322512MSB4SI; LCSC Part C9002

Connections:
+1V1: C6.2, C10.1, C11.1, C12.1, C13.1, L1.1, RP2350.6 (DVDD), RP2350.23 (DVDD), RP2350.39 (DVDD), RP2350.50 (VREG_FB)
+3.3V: C3.1, C5.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C62.2, C64.2, C383.1, C384.1, C385.1, C386.1, C387.1, C388.1, C389.1, C390.1, C391.1, C392.1, C393.1, C394.1, C395.1, C396.1, C397.1, C398.1, C399.1, C402.1, C403.1, C404.1, C405.1, C406.1, C407.1, C408.1, C409.1, C410.1, C411.1, C412.1, C413.1, C414.1, C415.1, C416.1, C417.1, C418.1, C419.1, C420.1, C421.1, C422.1, C423.1, C424.1, C546.1, C547.1, C548.1, Card1.4 (VDD), FLASH1.8 (VCC), FPC1.12, J1.1, LED1.2 (VDD), LED54.2 (VDD), R6.2, R28.1, R29.1, R30.1, R31.1, R36.1, R37.1, R40.1, R41.1, RP2350.1 (IOVDD), RP2350.11 (IOVDD), RP2350.20 (IOVDD), RP2350.30 (IOVDD), RP2350.38 (IOVDD), RP2350.44 (ADC_AVDD), RP2350.45 (IOVDD), RP2350.49 (VREG_VIN), RP2350.53 (USB_OTP_VDD), RP2350.54 (QSPI_IOVDD), U1.1 (VDD), U2.5 (VDDIO), U2.8 (VDD), U3.24 (VCC), U4.1 (VDD), U5.1 (VDD), U6.1 (VCCA), U6.5 (DIR), U7.1 (VDD), U8.1 (VDD), U9.1 (VDD), U10.1 (VDD), U11.1 (VDD), U12.5 (VOUT), U13.1 (VDD), U14.1 (VDD), U15.1 (VDD), U16.1 (VDD), U17.1 (VDD), U18.24 (VCC), U19.1 (VDD), U20.1 (VDD), U21.1 (VDD), U22.1 (VDD), U23.1 (VDD), U24.1 (VDD), U25.1 (VDD), U27.1 (VDD), U28.1 (VDD), U29.1 (VDD), U30.1 (VDD), U31.1 (VDD), U32.1 (VDD), U33.1 (VDD), U34.1 (VDD), U35.1 (VDD), U36.1 (VDD), U37.1 (VDD), U38.1 (VDD), U39.1 (VDD), U40.1 (VDD), U41.1 (VDD), U42.1 (VDD), U43.24 (VCC), U44.1 (VDD), U45.1 (VDD), U46.1 (VDD), U47.1 (VDD), U48.7 (VDD), U48.8 (VDD)
+5V: C65.2, C400.1, F1.2, FB1.1, U12.1 (VIN), U12.3 (EN)
+5V_LED: C82.1, C83.1, C84.1, C85.1, C86.1, C87.1, C88.1, C89.1, C90.1, C91.1, C92.1, C93.1, C94.1, C95.1, C96.1, C97.1, C98.1, C99.1, C100.1, C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, C107.1, C108.1, C109.1, C110.1, C111.1, C112.1, C113.1, C114.1, C115.1, C116.1, C117.1, C118.1, C119.1, C120.1, C122.1, C123.1, C124.1, C125.1, C126.1, C127.1, C128.1, C129.1, C130.1, C131.1, C132.1, C133.1, C134.1, C135.1, C136.1, C137.1, C138.1, C139.1, C140.1, C141.1, C142.1, C143.1, C144.1, C145.1, C146.1, C147.1, C148.1, C149.1, C150.1, C151.1, C152.1, C153.1, C154.1, C155.1, C156.1, C158.1, C159.1, C160.1, C161.1, C162.1, C163.1, C164.1, C165.1, C166.1, C167.1, C168.1, C169.1, C170.1, C171.1, C172.1, C173.1, C174.1, C175.1, C176.1, C177.1, C178.1, C179.1, C180.1, C181.1, C182.1, C183.1, C184.1, C185.1, C186.1, C187.1, C188.1, C189.1, C191.1, C192.1, C193.1, C194.1, C195.1, C196.1, C197.1, C198.1, C199.1, C200.1, C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, C209.1, C210.1, C212.1, C213.1, C214.1, C215.1, C216.1, C217.1, C218.1, C219.1, C220.1, C221.1, C222.1, C223.1, C224.1, C225.1, C226.1, C227.1, C228.1, C230.1, C231.1, C232.1, C233.1, C234.1, C235.1, C236.1, C237.1, C238.1, C239.1, C240.1, C241.1, C242.1, C243.1, C244.1, C245.1, C246.1, C247.1, C248.1, C249.1, C250.1, C251.1, C252.1, C253.1, C254.1, C255.1, C256.1, C257.1, C258.1, C259.1, C260.1, C261.1, C262.1, C263.1, C264.1, C265.1, C266.1, C267.1, C268.1, C269.1, C270.1, C271.1, C272.1, C273.1, C274.1, C275.1, C276.1, C277.1, C278.1, C279.1, C280.1, C281.1, C282.1, C283.1, C284.1, C285.1, C286.1, C287.1, C288.1, C289.1, C290.1, C291.1, C292.1, C293.1, C294.1, C295.1, C296.1, C297.1, C298.1, C299.1, C300.1, C301.1, C302.1, C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, C309.1, C310.1, C311.1, C312.1, C313.1, C314.1, C315.1, C316.1, C317.1, C318.1, C319.1, C320.1, C321.1, C322.1, C323.1, C324.1, C325.1, C326.1, C327.1, C328.1, C329.1, C330.1, C331.1, C332.1, C333.1, C334.1, C335.1, C336.1, C337.1, C338.1, C339.1, C340.1, C341.1, C342.1, C343.1, C344.1, C345.1, C346.1, C347.1, C348.1, C349.1, C350.1, C351.1, C352.1, C353.1, C354.1, C355.1, C356.1, C357.1, C358.1, C359.1, C360.1, C361.1, C362.1, C363.1, C364.1, C365.1, C366.1, C367.1, C368.1, C369.1, C370.1, C371.1, C372.1, C373.1, C374.1, C375.1, C376.1, C377.1, C378.1, C379.1, C380.1, C381.1, C382.1, C401.1, C425.1, C426.1, C427.1, C428.1, C429.1, C430.1, C431.1, C432.1, C433.1, C434.1, C435.1, C436.1, C437.1, C438.1, C439.1, C440.1, C441.1, C442.1, C443.1, C444.1, C445.1, C446.1, C447.1, C448.1, C449.1, C450.1, C451.1, C452.1, C453.1, C454.1, C455.1, C456.1, C457.1, C458.1, C459.1, C460.1, C461.1, C462.1, C463.1, C464.1, C465.1, C466.1, C467.1, C468.1, C469.1, C470.1, C471.1, C472.1, C473.1, C474.1, C475.1, C476.1, C477.1, C478.1, C479.1, C480.1, C481.1, C482.1, C483.1, C484.1, C485.1, C486.1, C487.1, C488.1, C489.1, C490.1, C491.1, C492.1, C493.1, C494.1, C495.1, C496.1, C497.1, C498.1, C499.1, C500.1, C501.1, C502.1, C503.1, C504.1, C505.1, C506.1, C507.1, C508.1, C509.1, C510.1, C511.1, C512.1, C513.1, C514.1, C515.1, C516.1, C517.1, C518.1, C519.1, C520.1, C521.1, C522.1, C523.1, C524.1, C525.1, C526.1, C527.1, C528.1, C529.1, C530.1, C531.1, C532.1, C533.1, C534.1, C535.1, C536.1, C537.1, C538.1, C539.1, C540.1, C541.1, C542.1, C543.1, C544.1, C549.1, C550.1, C551.1, C552.1, C553.1, C554.1, FB1.2, LED2.2 (VDD), LED3.2 (VDD), LED4.2 (VDD), LED5.2 (VDD), LED6.2 (VDD), LED7.2 (VDD), LED8.2 (VDD), LED9.2 (VDD), LED10.2 (VDD), LED11.2 (VDD), LED12.2 (VDD), LED13.2 (VDD), LED14.2 (VDD), LED15.2 (VDD), LED16.2 (VDD), LED17.2 (VDD), LED18.2 (VDD), LED19.2 (VDD), LED20.2 (VDD), LED21.2 (VDD), LED22.2 (VDD), LED23.2 (VDD), LED24.2 (VDD), LED25.2 (VDD), LED26.2 (VDD), LED27.2 (VDD), LED28.2 (VDD), LED29.2 (VDD), LED30.2 (VDD), LED31.2 (VDD), LED32.2 (VDD), LED33.2 (VDD), LED34.2 (VDD), LED35.2 (VDD), LED36.2 (VDD), LED37.2 (VDD), LED38.2 (VDD), LED39.2 (VDD), LED40.2 (VDD), LED41.2 (VDD), LED42.2 (VDD), LED43.2 (VDD), LED44.2 (VDD), LED45.2 (VDD), LED46.2 (VDD), LED47.2 (VDD), LED48.2 (VDD), LED49.2 (VDD)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
GND: C3.2, C4.1, C5.2, C6.1, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.1, C63.1, C64.1, C65.1, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.2, C90.2, C91.2, C92.2, C93.2, C94.2, C95.2, C96.2, C97.2, C98.2, C99.2, C100.2, C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C131.2, C132.2, C133.2, C134.2, C135.2, C136.2, C137.2, C138.2, C139.2, C140.2, C141.2, C142.2, C143.2, C144.2, C145.2, C146.2, C147.2, C148.2, C149.2, C150.2, C151.2, C152.2, C153.2, C154.2, C155.2, C156.2, C158.2, C159.2, C160.2, C161.2, C162.2, C163.2, C164.2, C165.2, C166.2, C167.2, C168.2, C169.2, C170.2, C171.2, C172.2, C173.2, C174.2, C175.2, C176.2, C177.2, C178.2, C179.2, C180.2, C181.2, C182.2, C183.2, C184.2, C185.2, C186.2, C187.2, C188.2, C189.2, C191.2, C192.2, C193.2, C194.2, C195.2, C196.2, C197.2, C198.2, C199.2, C200.2, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C223.2, C224.2, C225.2, C226.2, C227.2, C228.2, C230.2, C231.2, C232.2, C233.2, C234.2, C235.2, C236.2, C237.2, C238.2, C239.2, C240.2, C241.2, C242.2, C243.2, C244.2, C245.2, C246.2, C247.2, C248.2, C249.2, C250.2, C251.2, C252.2, C253.2, C254.2, C255.2, C256.2, C257.2, C258.2, C259.2, C260.2, C261.2, C262.2, C263.2, C264.2, C265.2, C266.2, C267.2, C268.2, C269.2, C270.2, C271.2, C272.2, C273.2, C274.2, C275.2, C276.2, C277.2, C278.2, C279.2, C280.2, C281.2, C282.2, C283.2, C284.2, C285.2, C286.2, C287.2, C288.2, C289.2, C290.2, C291.2, C292.2, C293.2, C294.2, C295.2, C296.2, C297.2, C298.2, C299.2, C300.2, C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, C320.2, C321.2, C322.2, C323.2, C324.2, C325.2, C326.2, C327.2, C328.2, C329.2, C330.2, C331.2, C332.2, C333.2, C334.2, C335.2, C336.2, C337.2, C338.2, C339.2, C340.2, C341.2, C342.2, C343.2, C344.2, C345.2, C346.2, C347.2, C348.2, C349.2, C350.2, C351.2, C352.2, C353.2, C354.2, C355.2, C356.2, C357.2, C358.2, C359.2, C360.2, C361.2, C362.2, C363.2, C364.2, C365.2, C366.2, C367.2, C368.2, C369.2, C370.2, C371.2, C372.2, C373.2, C374.2, C375.2, C376.2, C377.2, C378.2, C379.2, C380.2, C381.2, C383.2, C384.2, C385.2, C386.2, C387.2, C388.2, C389.2, C390.2, C391.2, C392.2, C393.2, C394.2, C395.2, C396.2, C397.2, C398.2, C399.2, C400.2, C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, C413.2, C414.2, C415.2, C416.2, C417.2, C418.2, C419.2, C420.2, C421.2, C422.2, C423.2, C424.2, C425.2, C426.2, C427.2, C428.2, C429.2, C430.2, C431.2, C432.2, C433.2, C434.2, C435.2, C436.2, C437.2, C438.2, C439.2, C440.2, C441.2, C442.2, C443.2, C444.2, C445.2, C446.2, C447.2, C448.2, C449.2, C450.2, C451.2, C452.2, C453.2, C454.2, C455.2, C456.2, C457.2, C458.2, C459.2, C460.2, C461.2, C462.2, C463.2, C464.2, C465.2, C466.2, C467.2, C468.2, C469.2, C470.2, C471.2, C472.2, C473.2, C474.2, C475.2, C476.2, C477.2, C478.2, C479.2, C480.2, C481.2, C482.2, C483.2, C484.2, C485.2, C486.2, C487.2, C488.2, C489.2, C490.2, C491.2, C492.2, C493.2, C494.2, C495.2, C496.2, C497.2, C498.2, C499.2, C500.2, C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, C513.2, C514.2, C515.2, C516.2, C517.2, C518.2, C519.2, C520.2, C521.2, C522.2, C523.2, C524.2, C525.2, C526.2, C527.2, C528.2, C529.2, C530.2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
I2C_SCL: FPC1.9, LED1.1 (SCL), R41.2, RP2350.37 (GPIO25)
I2C_SDA: FPC1.10, LED1.4 (SDA), R40.2, RP2350.36 (GPIO24)
I2S_BCLK: RP2350.8 (GPIO5), U48.16 (BCLK)
I2S_DIN: RP2350.7 (GPIO4), U48.1 (DIN)
I2S_LRCLK: RP2350.9 (GPIO6), U48.14 (LRCLK)
IMU_CS: RP2350.43 (GPIO29/ADC3), U2.12 (CS)
IMU_INT1: RP2350.34 (GPIO22), U2.4 (INT1)
LED_DATA: RP2350.27 (GPIO16), U6.3 (A)
LED_DIN_A: R13.2, U6.4 (B)
MUX_1: RP2350.40 (GPIO26/ADC0), U3.1 (COM)
MUX_2: RP2350.41 (GPIO27/ADC1), U18.1 (COM)
MUX_3: RP2350.42 (GPIO28/ADC2), U43.1 (COM)
MUX_S0: RP2350.2 (GPIO0), U3.10 (S0), U18.10 (S0), U43.10 (S0)
MUX_S1: RP2350.3 (GPIO1), U3.11 (S1), U18.11 (S1), U43.11 (S1)
MUX_S2: RP2350.4 (GPIO2), U3.14 (S2), U18.14 (S2), U43.14 (S2)
MUX_S3: RP2350.5 (GPIO3), U3.13 (S3), U18.13 (S3), U43.13 (S3)
Mute: RP2350.10 (GPIO7), U48.4 (~SD_MODE)
unnamed: C27.2, USB1.0 (SH), USB1.1 (SH), USB1.2 (SH), USB1.3 (SH)
unnamed: C62.1, C63.2
unnamed: C211.1, C382.2
unnamed: Card1.8 (DAT1), R28.2
unnamed: Card1.1 (DAT2), R29.2
unnamed: D1.1 (K), D7.1 (K), D12.1 (K), D16.1 (K), D20.1 (K), D24.1 (K), D28.1 (K), D32.1 (K), D36.1 (K), D40.1 (K), D43.1 (K), D50.1 (K)
unnamed: D1.2 (A), SW4.2
unnamed: D2.2 (A), SW5.2
unnamed: D3.2 (A), SW6.2
unnamed: D5.6 (I/O1), R34.1
unnamed: D5.4 (I/O2), R35.2
unnamed: D6.2 (A), SW8.2
unnamed: D7.2 (A), SW9.2
unnamed: D8.2 (A), SW10.2
unnamed: D9.2 (A), SW11.2
unnamed: D6.1 (K), D11.1 (K), D44.1 (K), D45.1 (K), D46.1 (K)
unnamed: D11.2 (A), SW13.2
unnamed: D12.2 (A), SW14.2
unnamed: D2.1 (K), D8.1 (K), D13.1 (K), D17.1 (K), D21.1 (K), D25.1 (K), D29.1 (K), D33.1 (K), D37.1 (K), D41.1 (K), D48.1 (K), D51.1 (K)
unnamed: D13.2 (A), SW15.2
unnamed: D3.1 (K), D9.1 (K), D14.1 (K), D18.1 (K), D22.1 (K), D26.1 (K), D30.1 (K), D34.1 (K), D38.1 (K), D42.1 (K), D49.1 (K), D52.1 (K)
unnamed: D14.2 (A), SW16.2
unnamed: D16.2 (A), SW18.2
unnamed: D17.2 (A), SW19.2
unnamed: D18.2 (A), SW20.2
unnamed: D20.2 (A), SW22.2
unnamed: D21.2 (A), SW23.2
unnamed: D22.2 (A), SW24.2
unnamed: D24.2 (A), SW26.2
unnamed: D25.2 (A), SW27.2
unnamed: D26.2 (A), SW28.2
unnamed: D28.2 (A), SW30.2
unnamed: D29.2 (A), SW31.2
unnamed: D30.2 (A), SW32.2
unnamed: D32.2 (A), SW34.2
unnamed: D33.2 (A), SW35.2
unnamed: D34.2 (A), SW36.2
unnamed: D36.2 (A), SW38.2
unnamed: D37.2 (A), SW39.2
unnamed: D38.2 (A), SW40.2
unnamed: D40.2 (A), SW42.2
unnamed: D41.2 (A), SW43.2
unnamed: D42.2 (A), SW44.2
unnamed: D43.2 (A), SW45.2
unnamed: D44.2 (A), SW46.2
unnamed: D45.2 (A), SW47.2
unnamed: D46.2 (A), SW48.2
unnamed: D48.2 (A), SW50.2
unnamed: D49.2 (A), SW51.2
unnamed: D50.2 (A), SW52.2
unnamed: D51.2 (A), SW53.2
unnamed: D52.2 (A), SW54.2
unnamed: FPC1.11, FPC1.14, SW1.C, SW1.E
unnamed: LED2.1 (DIN), R13.1
unnamed: LED2.3 (DOUT), LED3.1 (DIN)
unnamed: LED3.3 (DOUT), LED4.1 (DIN)
unnamed: LED4.3 (DOUT), LED5.1 (DIN)
unnamed: LED5.3 (DOUT), LED6.1 (DIN)
unnamed: LED6.3 (DOUT), LED7.1 (DIN)
unnamed: LED7.3 (DOUT), LED8.1 (DIN)
unnamed: LED8.3 (DOUT), LED9.1 (DIN)
unnamed: LED9.3 (DOUT), LED10.1 (DIN)
unnamed: LED10.3 (DOUT), LED11.1 (DIN)
unnamed: LED11.3 (DOUT), LED12.1 (DIN)
unnamed: LED12.3 (DOUT), LED13.1 (DIN)
unnamed: LED13.3 (DOUT), LED14.1 (DIN)
unnamed: LED14.3 (DOUT), LED16.1 (DIN)
unnamed: LED15.1 (DIN), LED20.3 (DOUT)
unnamed: LED15.3 (DOUT), LED17.1 (DIN)
unnamed: LED16.3 (DOUT), LED18.1 (DIN)
unnamed: LED17.3 (DOUT), LED19.1 (DIN)
unnamed: LED18.3 (DOUT), LED20.1 (DIN)
unnamed: LED19.3 (DOUT), LED21.1 (DIN)
unnamed: LED21.3 (DOUT), LED22.1 (DIN)
unnamed: LED22.3 (DOUT), LED24.1 (DIN)
unnamed: LED23.3 (DOUT), LED32.1 (DIN)
unnamed: LED24.3 (DOUT), LED26.1 (DIN)
unnamed: LED25.1 (DIN), LED49.3 (DOUT)
unnamed: LED25.3 (DOUT), LED33.1 (DIN)
unnamed: LED26.3 (DOUT), LED28.1 (DIN)
unnamed: LED27.1 (DIN), LED44.3 (DOUT)
unnamed: LED27.3 (DOUT), LED34.1 (DIN)
unnamed: LED29.1 (DIN), LED46.3 (DOUT)
unnamed: LED29.3 (DOUT), LED35.1 (DIN)
unnamed: LED30.1 (DIN), LED47.3 (DOUT)
unnamed: LED30.3 (DOUT), LED36.1 (DIN)
unnamed: LED31.1 (DIN), LED48.3 (DOUT)
unnamed: LED31.3 (DOUT), LED37.1 (DIN)
unnamed: LED32.3 (DOUT), LED38.1 (DIN)
unnamed: LED33.3 (DOUT), LED39.1 (DIN)
unnamed: LED34.3 (DOUT), LED40.1 (DIN)
unnamed: LED35.3 (DOUT), LED41.1 (DIN)
unnamed: LED36.3 (DOUT), LED42.1 (DIN)
unnamed: LED37.3 (DOUT), LED43.1 (DIN)
unnamed: LED38.3 (DOUT), LED44.1 (DIN)
unnamed: LED39.3 (DOUT), LED45.1 (DIN)
unnamed: LED40.3 (DOUT), LED46.1 (DIN)
unnamed: LED41.3 (DOUT), LED47.1 (DIN)
unnamed: LED42.3 (DOUT), LED48.1 (DIN)
unnamed: LED43.3 (DOUT), LED49.1 (DIN)
unnamed: LED50.3 (DOUT), LED56.1 (DIN)
unnamed: LED51.1 (DIN), LED73.3 (DOUT)
unnamed: LED51.3 (DOUT), LED57.1 (DIN)
unnamed: LED52.1 (DIN), LED68.3 (DOUT)
unnamed: LED52.3 (DOUT), LED58.1 (DIN)
unnamed: LED53.1 (DIN), LED70.3 (DOUT)
unnamed: LED53.3 (DOUT), LED59.1 (DIN)
unnamed: LED54.1 (DIN), R10.1
unnamed: LED55.1 (DIN), LED72.3 (DOUT)
unnamed: LED55.3 (DOUT), LED61.1 (DIN)
unnamed: LED56.3 (DOUT), LED62.1 (DIN)
unnamed: LED57.3 (DOUT), LED63.1 (DIN)
unnamed: LED58.3 (DOUT), LED64.1 (DIN)
unnamed: LED59.3 (DOUT), LED65.1 (DIN)
unnamed: LED60.1 (DIN), LED71.3 (DOUT)
unnamed: LED60.3 (DOUT), LED66.1 (DIN)
unnamed: LED61.3 (DOUT), LED67.1 (DIN)
unnamed: LED62.3 (DOUT), LED68.1 (DIN)
unnamed: LED63.3 (DOUT), LED69.1 (DIN)
unnamed: LED64.3 (DOUT), LED70.1 (DIN)
unnamed: LED65.3 (DOUT), LED71.1 (DIN)
unnamed: LED66.3 (DOUT), LED72.1 (DIN)
unnamed: LED67.3 (DOUT), LED73.1 (DIN)
unnamed: LED74.3 (DOUT), LED80.1 (DIN)
unnamed: LED75.1 (DIN), LED97.3 (DOUT)
unnamed: LED75.3 (DOUT), LED81.1 (DIN)
unnamed: LED76.1 (DIN), LED92.3 (DOUT)
unnamed: LED76.3 (DOUT), LED82.1 (DIN)
unnamed: LED77.1 (DIN), LED94.3 (DOUT)
unnamed: LED77.3 (DOUT), LED83.1 (DIN)
unnamed: LED78.1 (DIN), LED95.3 (DOUT)
unnamed: LED78.3 (DOUT), LED84.1 (DIN)
unnamed: LED79.1 (DIN), LED96.3 (DOUT)
unnamed: LED79.3 (DOUT), LED85.1 (DIN)
unnamed: LED80.3 (DOUT), LED92.1 (DIN)
unnamed: LED81.3 (DOUT), LED87.1 (DIN)
unnamed: LED82.3 (DOUT), LED88.1 (DIN)
unnamed: LED83.3 (DOUT), LED89.1 (DIN)
unnamed: LED84.3 (DOUT), LED90.1 (DIN)
unnamed: LED85.3 (DOUT), LED91.1 (DIN)
unnamed: LED87.3 (DOUT), LED93.1 (DIN)
unnamed: LED88.3 (DOUT), LED94.1 (DIN)
unnamed: LED89.3 (DOUT), LED95.1 (DIN)
unnamed: LED90.3 (DOUT), LED96.1 (DIN)
unnamed: LED91.3 (DOUT), LED97.1 (DIN)
unnamed: LED100.1 (DIN), LED116.3 (DOUT)
unnamed: LED100.3 (DOUT), LED106.1 (DIN)
unnamed: LED101.1 (DIN), LED118.3 (DOUT)
unnamed: LED101.3 (DOUT), LED107.1 (DIN)
unnamed: LED102.1 (DIN), LED119.3 (DOUT)
unnamed: LED102.3 (DOUT), LED108.1 (DIN)
unnamed: LED103.1 (DIN), LED120.3 (DOUT)
unnamed: LED103.3 (DOUT), LED109.1 (DIN)
unnamed: LED98.3 (DOUT), LED104.1 (DIN)
unnamed: LED104.3 (DOUT), LED110.1 (DIN)
unnamed: LED99.3 (DOUT), LED105.1 (DIN)
unnamed: LED105.3 (DOUT), LED111.1 (DIN)
unnamed: LED106.3 (DOUT), LED112.1 (DIN)
unnamed: LED107.3 (DOUT), LED113.1 (DIN)
unnamed: LED108.3 (DOUT), LED114.1 (DIN)
unnamed: LED109.3 (DOUT), LED115.1 (DIN)
unnamed: LED110.3 (DOUT), LED116.1 (DIN)
unnamed: LED111.3 (DOUT), LED117.1 (DIN)
unnamed: LED112.3 (DOUT), LED118.1 (DIN)
unnamed: LED113.3 (DOUT), LED119.1 (DIN)
unnamed: LED114.3 (DOUT), LED120.1 (DIN)
unnamed: LED115.3 (DOUT), LED121.1 (DIN)
unnamed: LED117.3 (DOUT), LED219.1 (DIN)
unnamed: LED99.1 (DIN), LED121.3 (DOUT)
unnamed: LED28.3 (DOUT), LED123.1 (DIN)
unnamed: LED123.3 (DOUT), LED129.1 (DIN)
unnamed: LED124.1 (DIN), LED146.3 (DOUT)
unnamed: LED124.3 (DOUT), LED130.1 (DIN)
unnamed: LED125.1 (DIN), LED141.3 (DOUT)
unnamed: LED125.3 (DOUT), LED131.1 (DIN)
unnamed: LED126.1 (DIN), LED143.3 (DOUT)
unnamed: LED126.3 (DOUT), LED132.1 (DIN)
unnamed: LED127.1 (DIN), LED144.3 (DOUT)
unnamed: LED127.3 (DOUT), LED133.1 (DIN)
unnamed: LED128.1 (DIN), LED139.3 (DOUT)
unnamed: LED128.3 (DOUT), LED134.1 (DIN)
unnamed: LED129.3 (DOUT), LED135.1 (DIN)
unnamed: LED130.3 (DOUT), LED136.1 (DIN)
unnamed: LED131.3 (DOUT), LED137.1 (DIN)
unnamed: LED132.3 (DOUT), LED138.1 (DIN)
unnamed: LED133.3 (DOUT), LED139.1 (DIN)
unnamed: LED134.3 (DOUT), LED140.1 (DIN)
unnamed: LED135.3 (DOUT), LED141.1 (DIN)
unnamed: LED136.3 (DOUT), LED142.1 (DIN)
unnamed: LED137.3 (DOUT), LED143.1 (DIN)
unnamed: LED138.3 (DOUT), LED144.1 (DIN)
unnamed: LED140.3 (DOUT), LED146.1 (DIN)
unnamed: LED23.1 (DIN), LED142.3 (DOUT)
unnamed: LED45.3 (DOUT), LED147.1 (DIN)
unnamed: LED147.3 (DOUT), LED153.1 (DIN)
unnamed: LED148.1 (DIN), LED170.3 (DOUT)
unnamed: LED148.3 (DOUT), LED154.1 (DIN)
unnamed: LED149.1 (DIN), LED159.3 (DOUT)
unnamed: LED149.3 (DOUT), LED155.1 (DIN)
unnamed: LED150.1 (DIN), LED167.3 (DOUT)
unnamed: LED150.3 (DOUT), LED156.1 (DIN)
unnamed: LED151.1 (DIN), LED168.3 (DOUT)
unnamed: LED151.3 (DOUT), LED157.1 (DIN)
unnamed: LED152.1 (DIN), LED169.3 (DOUT)
unnamed: LED152.3 (DOUT), LED158.1 (DIN)
unnamed: LED153.3 (DOUT), LED159.1 (DIN)
unnamed: LED154.3 (DOUT), LED160.1 (DIN)
unnamed: LED155.3 (DOUT), LED161.1 (DIN)
unnamed: LED156.3 (DOUT), LED162.1 (DIN)
unnamed: LED157.3 (DOUT), LED163.1 (DIN)
unnamed: LED158.3 (DOUT), LED164.1 (DIN)
unnamed: LED160.3 (DOUT), LED166.1 (DIN)
unnamed: LED161.3 (DOUT), LED167.1 (DIN)
unnamed: LED162.3 (DOUT), LED168.1 (DIN)
unnamed: LED163.3 (DOUT), LED169.1 (DIN)
unnamed: LED164.3 (DOUT), LED170.1 (DIN)
unnamed: LED50.1 (DIN), LED166.3 (DOUT)
unnamed: LED69.3 (DOUT), LED171.1 (DIN)
unnamed: LED171.3 (DOUT), LED177.1 (DIN)
unnamed: LED172.1 (DIN), LED194.3 (DOUT)
unnamed: LED172.3 (DOUT), LED178.1 (DIN)
unnamed: LED173.1 (DIN), LED189.3 (DOUT)
unnamed: LED173.3 (DOUT), LED179.1 (DIN)
unnamed: LED174.1 (DIN), LED191.3 (DOUT)
unnamed: LED174.3 (DOUT), LED180.1 (DIN)
unnamed: LED175.1 (DIN), LED192.3 (DOUT)
unnamed: LED175.3 (DOUT), LED181.1 (DIN)
unnamed: LED176.1 (DIN), LED193.3 (DOUT)
unnamed: LED176.3 (DOUT), LED182.1 (DIN)
unnamed: LED177.3 (DOUT), LED183.1 (DIN)
unnamed: LED178.3 (DOUT), LED184.1 (DIN)
unnamed: LED179.3 (DOUT), LED185.1 (DIN)
unnamed: LED180.3 (DOUT), LED186.4 (GND)
unnamed: LED181.3 (DOUT), LED187.1 (DIN)
unnamed: LED182.3 (DOUT), LED188.1 (DIN)
unnamed: LED183.3 (DOUT), LED189.1 (DIN)
unnamed: LED184.3 (DOUT), LED190.1 (DIN)
unnamed: LED185.3 (DOUT), LED191.1 (DIN)
unnamed: LED186.2 (VDD), LED192.1 (DIN)
unnamed: LED187.3 (DOUT), LED193.1 (DIN)
unnamed: LED188.3 (DOUT), LED194.1 (DIN)
unnamed: LED74.1 (DIN), LED190.3 (DOUT)
unnamed: LED93.3 (DOUT), LED195.1 (DIN)
unnamed: LED195.3 (DOUT), LED201.1 (DIN)
unnamed: LED196.1 (DIN), LED218.3 (DOUT)
unnamed: LED196.3 (DOUT), LED202.1 (DIN)
unnamed: LED197.1 (DIN), LED213.3 (DOUT)
unnamed: LED197.3 (DOUT), LED203.1 (DIN)
unnamed: LED198.1 (DIN), LED215.3 (DOUT)
unnamed: LED198.3 (DOUT), LED204.1 (DIN)
unnamed: LED199.1 (DIN), LED216.3 (DOUT)
unnamed: LED199.3 (DOUT), LED205.1 (DIN)
unnamed: LED200.1 (DIN), LED217.3 (DOUT)
unnamed: LED200.3 (DOUT), LED206.1 (DIN)
unnamed: LED201.3 (DOUT), LED207.1 (DIN)
unnamed: LED202.3 (DOUT), LED208.1 (DIN)
unnamed: LED203.3 (DOUT), LED209.1 (DIN)
unnamed: LED204.3 (DOUT), LED210.1 (DIN)
unnamed: LED205.3 (DOUT), LED211.1 (DIN)
unnamed: LED206.3 (DOUT), LED212.1 (DIN)
unnamed: LED207.3 (DOUT), LED213.1 (DIN)
unnamed: LED208.3 (DOUT), LED214.1 (DIN)
unnamed: LED209.3 (DOUT), LED215.1 (DIN)
unnamed: LED210.3 (DOUT), LED216.1 (DIN)
unnamed: LED211.3 (DOUT), LED217.1 (DIN)
unnamed: LED212.3 (DOUT), LED218.1 (DIN)
unnamed: LED98.1 (DIN), LED214.3 (DOUT)
unnamed: LED219.3 (DOUT), LED225.1 (DIN)
unnamed: LED220.1 (DIN), LED242.3 (DOUT)
unnamed: LED220.3 (DOUT), LED393.1 (DIN)
unnamed: LED221.1 (DIN), LED395.3 (DOUT)
unnamed: LED221.3 (DOUT), LED227.1 (DIN)
unnamed: LED222.1 (DIN), LED239.3 (DOUT)
unnamed: LED222.3 (DOUT), LED228.1 (DIN)
unnamed: LED223.1 (DIN), LED240.3 (DOUT)
unnamed: LED223.3 (DOUT), LED229.1 (DIN)
unnamed: LED224.1 (DIN), LED241.3 (DOUT)
unnamed: LED224.3 (DOUT), LED230.1 (DIN)
unnamed: LED225.3 (DOUT), LED394.1 (DIN)
unnamed: LED226.1 (DIN), LED393.3 (DOUT)
unnamed: LED226.3 (DOUT), LED232.1 (DIN)
unnamed: LED227.3 (DOUT), LED233.1 (DIN)
unnamed: LED228.3 (DOUT), LED234.1 (DIN)
unnamed: LED229.3 (DOUT), LED235.1 (DIN)
unnamed: LED230.3 (DOUT), LED236.1 (DIN)
unnamed: LED231.1 (DIN), LED394.3 (DOUT)
unnamed: LED231.3 (DOUT), LED237.1 (DIN)
unnamed: LED232.3 (DOUT), LED238.1 (DIN)
unnamed: LED233.3 (DOUT), LED239.1 (DIN)
unnamed: LED234.3 (DOUT), LED240.1 (DIN)
unnamed: LED235.3 (DOUT), LED241.1 (DIN)
unnamed: LED236.3 (DOUT), LED242.1 (DIN)
unnamed: LED237.3 (DOUT), LED395.1 (DIN)
unnamed: LED238.3 (DOUT), LED245.1 (DIN)
unnamed: LED243.1 (DIN), LED282.3 (DOUT)
unnamed: LED243.3 (DOUT), LED255.1 (DIN)
unnamed: LED244.1 (DIN), LED286.3 (DOUT)
unnamed: LED244.3 (DOUT), LED256.1 (DIN)
unnamed: LED245.3 (DOUT), LED257.1 (DIN)
unnamed: LED246.1 (DIN), LED290.3 (DOUT)
unnamed: LED246.3 (DOUT), LED258.1 (DIN)
unnamed: LED247.1 (DIN), LED279.3 (DOUT)
unnamed: LED247.3 (DOUT), LED259.1 (DIN)
unnamed: LED248.1 (DIN), LED283.3 (DOUT)
unnamed: LED248.3 (DOUT), LED260.1 (DIN)
unnamed: LED249.1 (DIN), LED284.3 (DOUT)
unnamed: LED249.3 (DOUT), LED261.1 (DIN)
unnamed: LED250.1 (DIN), LED285.3 (DOUT)
unnamed: LED250.3 (DOUT), LED262.1 (DIN)
unnamed: LED251.1 (DIN), LED281.3 (DOUT)
unnamed: LED251.3 (DOUT), LED263.1 (DIN)
unnamed: LED252.1 (DIN), LED287.3 (DOUT)
unnamed: LED252.3 (DOUT), LED264.1 (DIN)
unnamed: LED253.1 (DIN), LED288.3 (DOUT)
unnamed: LED253.3 (DOUT), LED265.1 (DIN)
unnamed: LED254.1 (DIN), LED289.3 (DOUT)
unnamed: LED254.3 (DOUT), LED266.1 (DIN)
unnamed: LED255.3 (DOUT), LED267.1 (DIN)
unnamed: LED256.3 (DOUT), LED268.1 (DIN)
unnamed: LED257.3 (DOUT), LED269.1 (DIN)
unnamed: LED258.3 (DOUT), LED270.1 (DIN)
unnamed: LED259.3 (DOUT), LED271.1 (DIN)
unnamed: LED260.3 (DOUT), LED272.1 (DIN)
unnamed: LED261.3 (DOUT), LED273.1 (DIN)
unnamed: LED262.3 (DOUT), LED274.1 (DIN)
unnamed: LED263.3 (DOUT), LED275.1 (DIN)
unnamed: LED264.3 (DOUT), LED276.1 (DIN)
unnamed: LED265.3 (DOUT), LED392.1 (DIN)
unnamed: LED266.3 (DOUT), LED278.1 (DIN)
unnamed: LED267.3 (DOUT), LED279.1 (DIN)
unnamed: LED268.3 (DOUT), LED280.1 (DIN)
unnamed: LED269.3 (DOUT), LED281.1 (DIN)
unnamed: LED270.3 (DOUT), LED282.1 (DIN)
unnamed: LED271.3 (DOUT), LED283.1 (DIN)
unnamed: LED272.3 (DOUT), LED284.1 (DIN)
unnamed: LED273.3 (DOUT), LED285.1 (DIN)
unnamed: LED274.3 (DOUT), LED286.1 (DIN)
unnamed: LED275.3 (DOUT), LED287.1 (DIN)
unnamed: LED276.3 (DOUT), LED288.1 (DIN)
unnamed: LED277.1 (DIN), LED392.3 (DOUT)
unnamed: LED277.3 (DOUT), LED289.1 (DIN)
unnamed: LED278.3 (DOUT), LED290.1 (DIN)
unnamed: LED280.3 (DOUT), LED291.1 (DIN)
unnamed: LED291.3 (DOUT), LED303.1 (DIN)
unnamed: LED292.1 (DIN), LED332.3 (DOUT)
unnamed: LED292.3 (DOUT), LED304.1 (DIN)
unnamed: LED293.1 (DIN), LED327.3 (DOUT)
unnamed: LED293.3 (DOUT), LED305.1 (DIN)
unnamed: LED294.1 (DIN), LED329.3 (DOUT)
unnamed: LED294.3 (DOUT), LED306.1 (DIN)
unnamed: LED295.1 (DIN), LED330.3 (DOUT)
unnamed: LED295.3 (DOUT), LED307.1 (DIN)
unnamed: LED296.1 (DIN), LED331.3 (DOUT)
unnamed: LED296.3 (DOUT), LED308.1 (DIN)
unnamed: LED297.1 (DIN), LED328.3 (DOUT)
unnamed: LED297.3 (DOUT), LED309.1 (DIN)
unnamed: LED298.1 (DIN), LED338.3 (DOUT)
unnamed: LED298.3 (DOUT), LED310.1 (DIN)
unnamed: LED299.1 (DIN), LED333.3 (DOUT)
unnamed: LED299.3 (DOUT), LED311.1 (DIN)
unnamed: LED300.1 (DIN), LED335.3 (DOUT)
unnamed: LED300.3 (DOUT), LED312.1 (DIN)
unnamed: LED301.1 (DIN), LED336.3 (DOUT)
unnamed: LED301.3 (DOUT), LED388.1 (DIN)
unnamed: LED302.1 (DIN), LED337.3 (DOUT)
unnamed: LED302.3 (DOUT), LED314.1 (DIN)
unnamed: LED303.3 (DOUT), LED315.1 (DIN)
unnamed: LED304.3 (DOUT), LED316.1 (DIN)
unnamed: LED305.3 (DOUT), LED317.1 (DIN)
unnamed: LED306.3 (DOUT), LED318.1 (DIN)
unnamed: LED307.3 (DOUT), LED319.1 (DIN)
unnamed: LED308.3 (DOUT), LED320.1 (DIN)
unnamed: LED309.3 (DOUT), LED321.1 (DIN)
unnamed: LED310.3 (DOUT), LED322.1 (DIN)
unnamed: LED311.3 (DOUT), LED323.1 (DIN)
unnamed: LED312.3 (DOUT), LED324.1 (DIN)
unnamed: LED313.1 (DIN), LED388.3 (DOUT)
unnamed: LED313.3 (DOUT), LED325.1 (DIN)
unnamed: LED314.3 (DOUT), LED326.1 (DIN)
unnamed: LED315.3 (DOUT), LED327.1 (DIN)
unnamed: LED316.3 (DOUT), LED328.1 (DIN)
unnamed: LED317.3 (DOUT), LED329.1 (DIN)
unnamed: LED318.3 (DOUT), LED330.1 (DIN)
unnamed: LED319.3 (DOUT), LED331.1 (DIN)
unnamed: LED320.3 (DOUT), LED332.1 (DIN)
unnamed: LED321.3 (DOUT), LED333.1 (DIN)
unnamed: LED322.3 (DOUT), LED334.1 (DIN)
unnamed: LED323.3 (DOUT), LED335.1 (DIN)
unnamed: LED324.3 (DOUT), LED336.1 (DIN)
unnamed: LED325.3 (DOUT), LED337.1 (DIN)
unnamed: LED326.3 (DOUT), LED338.1 (DIN)
unnamed: LED334.3 (DOUT), LED341.1 (DIN)
unnamed: LED339.1 (DIN), LED378.3 (DOUT)
unnamed: LED339.3 (DOUT), LED351.1 (DIN)
unnamed: LED340.1 (DIN), LED396.3 (DOUT)
unnamed: LED340.3 (DOUT), LED352.1 (DIN)
unnamed: LED341.3 (DOUT), LED353.1 (DIN)
unnamed: LED342.1 (DIN), LED386.3 (DOUT)
unnamed: LED342.3 (DOUT), LED354.1 (DIN)
unnamed: LED343.1 (DIN), LED375.3 (DOUT)
unnamed: LED343.3 (DOUT), LED355.1 (DIN)
unnamed: LED344.1 (DIN), LED379.3 (DOUT)
unnamed: LED344.3 (DOUT), LED356.1 (DIN)
unnamed: LED345.1 (DIN), LED391.3 (DOUT)
unnamed: LED345.3 (DOUT), LED357.1 (DIN)
unnamed: LED346.1 (DIN), LED381.3 (DOUT)
unnamed: LED346.3 (DOUT), LED358.1 (DIN)
unnamed: LED347.1 (DIN), LED377.3 (DOUT)
unnamed: LED347.3 (DOUT), LED359.1 (DIN)
unnamed: LED348.1 (DIN), LED383.3 (DOUT)
unnamed: LED348.3 (DOUT), LED360.1 (DIN)
unnamed: LED349.1 (DIN), LED384.3 (DOUT)
unnamed: LED349.3 (DOUT), LED361.1 (DIN)
unnamed: LED350.1 (DIN), LED385.3 (DOUT)
unnamed: LED350.3 (DOUT), LED362.1 (DIN)
unnamed: LED351.3 (DOUT), LED363.1 (DIN)
unnamed: LED352.3 (DOUT), LED364.1 (DIN)
unnamed: LED353.3 (DOUT), LED365.1 (DIN)
unnamed: LED354.3 (DOUT), LED366.1 (DIN)
unnamed: LED355.3 (DOUT), LED367.1 (DIN)
unnamed: LED356.3 (DOUT), LED368.1 (DIN)
unnamed: LED357.3 (DOUT), LED369.1 (DIN)
unnamed: LED358.3 (DOUT), LED370.1 (DIN)
unnamed: LED359.3 (DOUT), LED371.1 (DIN)
unnamed: LED360.3 (DOUT), LED389.1 (DIN)
unnamed: LED361.3 (DOUT), LED373.1 (DIN)
unnamed: LED362.3 (DOUT), LED374.1 (DIN)
unnamed: LED363.3 (DOUT), LED375.1 (DIN)
unnamed: LED364.3 (DOUT), LED376.1 (DIN)
unnamed: LED365.3 (DOUT), LED377.1 (DIN)
unnamed: LED366.3 (DOUT), LED378.1 (DIN)
unnamed: LED367.3 (DOUT), LED379.1 (DIN)
unnamed: LED368.3 (DOUT), LED380.1 (DIN)
unnamed: LED369.3 (DOUT), LED381.1 (DIN)
unnamed: LED370.3 (DOUT), LED382.1 (DIN)
unnamed: LED371.3 (DOUT), LED383.1 (DIN)
unnamed: LED372.1 (DIN), LED389.3 (DOUT)
unnamed: LED372.3 (DOUT), LED384.1 (DIN)
unnamed: LED373.3 (DOUT), LED385.1 (DIN)
unnamed: LED374.3 (DOUT), LED386.1 (DIN)
unnamed: LED376.3 (DOUT), LED387.1 (DIN)
unnamed: LED380.3 (DOUT), LED391.1 (DIN)
unnamed: LED382.3 (DOUT), LED396.1 (DIN)
unnamed: LED387.3 (DOUT), LED399.1 (DIN)
unnamed: LED390.1 (DIN), LED411.3 (DOUT)
unnamed: LED390.3 (DOUT), LED402.1 (DIN)
unnamed: LED399.3 (DOUT), LED411.1 (DIN)
unnamed: LED402.3 (DOUT), LED414.1 (DIN)
unnamed: LED414.3 (DOUT), LED426.1 (DIN)
unnamed: LED426.3 (DOUT), LED435.1 (DIN)
unnamed: LED435.3 (DOUT), LED447.1 (DIN)
unnamed: LED436.1 (DIN), LED478.3 (DOUT)
unnamed: LED436.3 (DOUT), LED448.1 (DIN)
unnamed: LED437.1 (DIN), LED472.3 (DOUT)
unnamed: LED437.3 (DOUT), LED449.1 (DIN)
unnamed: LED439.1 (DIN), LED471.3 (DOUT)
unnamed: LED439.3 (DOUT), LED443.1 (DIN)
unnamed: LED440.1 (DIN), LED475.3 (DOUT)
unnamed: LED440.3 (DOUT), LED452.1 (DIN)
unnamed: LED441.1 (DIN), LED476.3 (DOUT)
unnamed: LED441.3 (DOUT), LED453.1 (DIN)
unnamed: LED442.1 (DIN), LED477.3 (DOUT)
unnamed: LED442.3 (DOUT), LED454.1 (DIN)
unnamed: LED443.3 (DOUT), LED451.1 (DIN)
unnamed: LED447.3 (DOUT), LED459.1 (DIN)
unnamed: LED448.3 (DOUT), LED460.1 (DIN)
unnamed: LED451.3 (DOUT), LED463.1 (DIN)
unnamed: LED452.3 (DOUT), LED464.1 (DIN)
unnamed: LED453.3 (DOUT), LED477.1 (DIN)
unnamed: LED454.3 (DOUT), LED466.1 (DIN)
unnamed: LED459.3 (DOUT), LED471.1 (DIN)
unnamed: LED460.3 (DOUT), LED472.1 (DIN)
unnamed: LED463.3 (DOUT), LED475.1 (DIN)
unnamed: LED464.3 (DOUT), LED476.1 (DIN)
unnamed: LED466.3 (DOUT), LED478.1 (DIN)
unnamed: R3.2, SW3.1
unnamed: R8.2, SW2.3
unnamed: C4.2, R6.1, RP2350.46 (VREG_AVDD)
unnamed: L1.2, RP2350.48 (VREG_LX)
unnamed: SPK1.1 (+), U48.9 (OUTP)
unnamed: SPK1.2 (-), U48.10 (OUTN)
unnamed: SW4.1, SW5.1, SW6.1
unnamed: SW9.1, SW10.1, SW11.1
unnamed: SW13.1, SW22.1, SW23.1, SW24.1
unnamed: SW14.1, SW15.1, SW16.1
unnamed: SW18.1, SW19.1, SW20.1, SW46.1
unnamed: SW8.1, SW26.1, SW27.1, SW28.1
unnamed: SW30.1, SW31.1, SW32.1, SW47.1
unnamed: SW34.1, SW35.1, SW36.1, SW48.1
unnamed: SW38.1, SW39.1, SW40.1
unnamed: SW42.1, SW43.1, SW44.1
unnamed: SW45.1, SW50.1, SW51.1
unnamed: SW52.1, SW53.1, SW54.1
unnamed: U1.2 (OUT), U3.9 (I0)
unnamed: U3.8 (I1), U4.2 (OUT)
unnamed: U3.7 (I2), U5.2 (OUT)
unnamed: U3.6 (I3), U7.2 (OUT)
unnamed: U3.5 (I4), U8.2 (OUT)
unnamed: U3.4 (I5), U9.2 (OUT)
unnamed: U3.3 (I6), U10.2 (OUT)
unnamed: U3.2 (I7), U11.2 (OUT)
unnamed: U3.23 (I8), U13.2 (OUT)
unnamed: U3.22 (I9), U14.2 (OUT)
unnamed: U3.21 (I10), U15.2 (OUT)
unnamed: U3.20 (I11), U16.2 (OUT)
unnamed: U3.19 (I12), U17.2 (OUT)
unnamed: U18.9 (I0), U19.2 (OUT)
unnamed: U18.8 (I1), U20.2 (OUT)
unnamed: U18.7 (I2), U21.2 (OUT)
unnamed: U18.6 (I3), U22.2 (OUT)
unnamed: U18.5 (I4), U23.2 (OUT)
unnamed: U18.4 (I5), U24.2 (OUT)
unnamed: U18.3 (I6), U25.2 (OUT)
unnamed: U18.23 (I8), U27.2 (OUT)
unnamed: U18.22 (I9), U28.2 (OUT)
unnamed: U18.21 (I10), U29.2 (OUT)
unnamed: U18.20 (I11), U30.2 (OUT)
unnamed: U31.2 (OUT), U43.16 (I15)
unnamed: U32.2 (OUT), U43.17 (I14)
unnamed: U33.2 (OUT), U43.18 (I13)
unnamed: U34.2 (OUT), U43.9 (I0)
unnamed: U35.2 (OUT), U43.8 (I1)
unnamed: U36.2 (OUT), U43.7 (I2)
unnamed: U37.2 (OUT), U43.6 (I3)
unnamed: U38.2 (OUT), U43.5 (I4)
unnamed: U39.2 (OUT), U43.4 (I5)
unnamed: U40.2 (OUT), U43.3 (I6)
unnamed: U41.2 (OUT), U43.2 (I7)
unnamed: U42.2 (OUT), U43.23 (I8)
unnamed: U43.22 (I9), U45.2 (OUT)
unnamed: U43.21 (I10), U46.2 (OUT)
unnamed: U43.20 (I11), U47.2 (OUT)
unnamed: U43.19 (I12), U44.2 (OUT)
unnamed: R32.1, USB1.A5 (CC1)
unnamed: R33.2, USB1.B5 (CC2)
unnamed: C7.2, R7.1, X1.3 (OSC2)
RP2350_QSPI_SCLK: FLASH1.6 (CLK), RP2350.56 (QSPI_SCLK)
RP2350_QSPI_SD0: FLASH1.5 (DI/IO_{0}), RP2350.57 (QSPI_SD0)
RP2350_QSPI_SD1: FLASH1.2 (DO/IO_{1}), RP2350.59 (QSPI_SD1)
RP2350_QSPI_SD2: FLASH1.3 (~WP/IO_{2}), RP2350.58 (QSPI_SD2)
RP2350_QSPI_SD3: FLASH1.7 (~HOLD/~RESET/IO_{3}), RP2350.55 (QSPI_SD3)
RP2350_QSPI_SS: FLASH1.1 (~CS), R3.1, RP2350.60 (~QSPI_SS)
RP2350_RUN: C9.1, J1.5, RP2350.26 (RUN), SW2.1
RP2350_SWCLK: J1.3, RP2350.24 (SWCLK)
RP2350_SWDIO: J1.4, RP2350.25 (SWDIO)
RP2350_USB_DN: R34.2, RP2350.51 (USB_DM)
RP2350_USB_DP: R35.1, RP2350.52 (USB_DP)
RP2350_XIN: C8.2, RP2350.21 (XIN), X1.1 (OSC1)
RP2350_XOUT: R7.2, RP2350.22 (XOUT)
SD_CD: Card1.CD, R30.2, RP2350.28 (GPIO17), TP22.1 (1_1)
SD_CS: Card1.2 (CD/DAT3), R31.2, RP2350.29 (GPIO18), TP18.1 (1_1)
SPI_MISO: Card1.7 (DAT0), R37.2, RP2350.33 (GPIO21), TP21.1 (1_1), U2.1 (SDO/SA0)
SPI_MOSI: Card1.3 (CMD), R36.2, RP2350.32 (GPIO20), TP19.1 (1_1), U2.14 (SDA)
SPI_SCK: Card1.5 (CLX), RP2350.31 (GPIO19), TP20.1 (1_1), U2.13 (SCL)
STATUS: R10.2, RP2350.35 (GPIO23)
SW1: RP2350.19 (GPIO15), SW41.1
SW2: RP2350.18 (GPIO14), SW49.1
SW3: RP2350.17 (GPIO13), SW55.1
SW4: RP2350.16 (GPIO12), SW56.1
SW5: RP2350.15 (GPIO11), SW57.1
SW6: RP2350.14 (GPIO10), SW58.1
SW7: RP2350.13 (GPIO9), SW59.1
SW8: RP2350.12 (GPIO8), SW60.1
USB_D+: D5.3 (I/O2), USB1.A6 (DP1), USB1.B6 (DP2)
USB_D-: D5.1 (I/O1), USB1.A7 (DN1), USB1.B7 (DN2)
USB_VBUS: D5.5 (VBUS), F1.1, USB1.A4 (VBUS), USB1.A9 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS)

Notes on the sheet:
Keyboard Hall-Effect Sensors
ESD Protection
RP2350
3.3V-5V SIGNAL
IMU
Cirque Trackball
Light Sensor
STATUS
RP2350 DEBUG
RP2350 CRYSTAL
1.1V DECOUPLING
KEYS
BUTTONS
FLASH RAM
SD Card
3.3V REG
3.3V DECOUPLING
LEDS
USB-C Connector
ENCODER
